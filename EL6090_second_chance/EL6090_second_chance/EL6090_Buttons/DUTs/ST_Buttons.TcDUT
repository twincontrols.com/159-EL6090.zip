TYPE ST_Buttons :
STRUCT
	bUp    : BOOL;
	bDown  : BOOL;	
	bLeft  : BOOL;	
	bRight : BOOL;	
	bEnter : BOOL;
END_STRUCT
END_TYPE
