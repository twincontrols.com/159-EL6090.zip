PROGRAM MAIN
VAR
	
END_VAR

stButtons.bUp := IgbUp;
stButtons.bDown := IgbDown;
stButtons.bLeft := IgbLeft;
stButtons.bRight := IgbRight;
stButtons.bEnter := IgbEnter;

END_PROGRAM
